Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-09-28T09:09:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 28 09:09:55 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\ec809f43-7ef8-48c9-b2ee-83e92a76eab2\a1163042-0ce4-498c-9cc9-3cc30da53b6b\ifc * Database version: 5507 * Database creation date: Wed Sep 28 09:09:54 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 28 09:09:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 28 09:09:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11097640_D_PTD702_AE:61070201_D_11097640_PTD702_AE, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 61070201_D_11097640_PTD702_AE
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 61070201_D_11097640_PTD702_AE
Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Glass Black, z_Miele_Design_GRGR
Pset_BuildingElementProxyCommon - sets with these values: 2
